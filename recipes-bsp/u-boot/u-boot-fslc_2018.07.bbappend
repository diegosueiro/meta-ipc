SRC_URI = "git://github.com/diegosueiro/u-boot-fslc.git;branch=${SRCBRANCH}"

SRCREV = "b4a1dcc916119ae9949462bab723371743df8a23"
SRCBRANCH = "2018.07+fslc"
